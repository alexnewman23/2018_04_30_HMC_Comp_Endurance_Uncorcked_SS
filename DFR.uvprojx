# Keil uVision project DFR.uvprojx, settings and files
target STM32F446xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: DFR
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F446xx HSI_VALUE=16000000
  c misc: --C99
  c include: .\RTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group STM32F4xx_StdPeriph_Driver
    ./: stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c stm32f4xx_spi.c
  group CMSIS
    ./: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f446xx.s
  group User
    ./: main.c stdout_USART.c Buttons_NUCLEO-F446RE.c LED_NUCLEO-F446RE.c HMC_state_machine.c HMC_state_machine.h ring_buffer.h ring_buffer.c DFR_SPI.c safety.h safety.c msg_safety_jj.c msg_safety_jj.h gear.h gear.c
    ./RTE/_STM32F446xx/: RTE_Components.h
software components: CMSIS:CORE 5.0.0, Compiler:I/O:STDOUT 1.1.0
